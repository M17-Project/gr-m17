options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: qt_gui
    id: m17_noisy
    output_language: python
    title: M17 loopback demo
  states: {}

blocks:
- name: dst_str
  id: variable_qtgui_entry
  parameters:
    label: DST
    type: string
    value: AB2CDE
  states: {}
- name: meta_str
  id: variable_qtgui_entry
  parameters:
    label: META
    type: string
    value: Hello!
  states: {}
- name: noise_ampl
  id: variable_qtgui_range
  parameters:
    label: Noise amplitude
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: src_str
  id: variable_qtgui_entry
  parameters:
    label: SRC
    type: string
    value: AB1CDE
  states: {}
- name: type_val
  id: variable_qtgui_entry
  parameters:
    label: TYPE
    type: int
    value: '5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_ampl
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/dump.bin
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: samp_rate/4
    type: byte
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f)
  states: {}
- name: btn0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Stop
    msgName: pressed
    type: string
    value: '1'
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: '0'
    debug: 'False'
    dst_id: dst_str
    encr_subtype: '0'
    encr_type: '0'
    key: ''
    meta: meta_str
    mode: '1'
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: src_str
    type: '2'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'False'
    debug_data: 'False'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    threshold: '2.0'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    label1: Eye diagram
    legend: 'False'
    samp_per_symbol: '1'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', m17_m17_decoder_0, '0']
- [blocks_add_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [blocks_throttle2_0, '0', m17_m17_coder_0, '0']
- [blocks_vector_source_x_0_2, '0', blocks_throttle2_0, '0']
- [btn0, pressed, m17_m17_coder_0, end_of_transmission]
- [m17_m17_coder_0, '0', blocks_add_xx_0, '0']
- [m17_m17_decoder_0, '0', blocks_file_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']
- [m17_m17_decoder_0, fields, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
