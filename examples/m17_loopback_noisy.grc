options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Project, Jan 2024
    generate_options: qt_gui
    id: m17_streamer
    output_language: python
    title: M17 loopback demo
  states: {}

blocks:
- name: dst_str
  id: variable_qtgui_entry
  parameters:
    label: DST
    type: string
    value: AB2CDE
  states: {}
- name: meta_str
  id: variable_qtgui_entry
  parameters:
    label: META
    type: string
    value: Hello!
  states: {}
- name: noise_ampl
  id: variable_qtgui_range
  parameters:
    label: Noise amplitude
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: src_str
  id: variable_qtgui_entry
  parameters:
    label: SRC
    type: string
    value: AB1CDE
  states: {}
- name: type_val
  id: variable_qtgui_entry
  parameters:
    label: TYPE
    type: int
    value: '5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_ampl
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/dump.bin
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    debug: 'False'
    dst_id: dst_str
    meta: meta_str
    src_id: src_str
    type: type_val
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    debug_ctrl: 'True'
    debug_data: 'False'
    threshold: '2.0'
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    label1: Eye diagram
    legend: 'False'
    samp_per_symbol: '1'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', m17_m17_decoder_0, '0']
- [blocks_add_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_vector_source_x_0_2, '0', m17_m17_coder_0, '0']
- [m17_m17_coder_0, '0', blocks_throttle2_0, '0']
- [m17_m17_decoder_0, '0', blocks_file_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
