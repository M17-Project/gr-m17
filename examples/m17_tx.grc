options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Project, Jan 2024
    generate_options: qt_gui
    id: m17_tx
    output_language: python
    title: M17 loopback demo
  states: {}

blocks:
- name: dst_str
  id: variable_qtgui_entry
  parameters:
    label: DST
    type: string
    value: AB2CDE
  states: {}
- name: meta_str
  id: variable_qtgui_entry
  parameters:
    label: META
    type: string
    value: Hello!
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: src_str
  id: variable_qtgui_entry
  parameters:
    label: SRC
    type: string
    value: AB1CDE
  states: {}
- name: type_val
  id: variable_qtgui_entry
  parameters:
    label: TYPE
    type: int
    value: '5'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      /tmp/fifo2 was created with
      mkfifo /tmp/fifo2
    file: /tmp/fifo2
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: end_of_transmission
  id: variable_qtgui_msg_push_button
  parameters:
    label: End of Transmission
    msgName: end_of_transmission
    type: string
    value: end_of_transmission
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: '0'
    debug: 'False'
    dst_id: dst_str
    encr_subtype: '0'
    encr_type: '0'
    eot_cnt: '1'
    key: '''\x00\x00\x65\x41\xb0\x93\xff\x00'''
    meta: meta_str
    mode: '1'
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: src_str
    type: type_val
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}

connections:
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0_2, '0', m17_m17_coder_0, '0']
- [end_of_transmission, pressed, m17_m17_coder_0, transmission_control]
- [m17_m17_coder_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
