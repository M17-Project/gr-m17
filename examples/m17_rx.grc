options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Project, Jan 2024
    generate_options: qt_gui
    id: m17_rx
    output_language: python
    title: M17 rx demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/dump.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      /tmp/fifo2 was created with
      mkfifo /tmp/fifo2
    file: /tmp/fifo2
    repeat: 'True'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'False'
    debug_ctrl: 'True'
    debug_data: 'False'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    threshold: '2.0'
  states: {}

connections:
- [blocks_file_source_0, '0', m17_m17_decoder_0, '0']
- [m17_m17_decoder_0, '0', blocks_file_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
