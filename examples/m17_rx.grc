options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2026
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: m17_rx
    output_language: python
    title: M17 RX demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/dump.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      /tmp/fifo2 was created with
      mkfifo /tmp/fifo2
    file: /tmp/fifo2
    repeat: 'True'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'True'
    debug_data: 'False'
    key: ''
    pub_key: ''
    seed: ''
    sw_threshold: '2.0'
    undecodable_out: '0'
    vt_threshold: '30.0'
  states: {}

connections:
- [blocks_file_source_0, '0', m17_m17_decoder_0, '0']
- [m17_m17_decoder_0, '0', blocks_file_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
