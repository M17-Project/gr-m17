options:
  parameters:
    author: SP5WWP
    copyright: M17 Project, Dec 2022
    generate_options: qt_gui
    id: m17_streamer
    output_language: python
    title: M17 data streamer
  states: {}

blocks:
- name: META
  id: variable
  parameters:
    value: '"helloworld"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: symbol rate
    value: '4800'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    comment: Data to be transmitted
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    dst_ip: 255.255.255.255.255.255
    meta: META
    samp_rate: samp_rate
    src_ip: 01.02.03.04.05.06
    type: '0'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters: {}
  states: {}

connections:
- [blocks_throttle_0, '0', m17_m17_coder_0, '0']
- [blocks_vector_source_x_0_2, '0', blocks_throttle_0, '0']
- [m17_m17_coder_0, '0', m17_m17_decoder_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
