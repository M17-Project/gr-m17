options:
  parameters:
    author: SP5WWP
    copyright: M17 Project, Dec 2022
    generate_options: qt_gui
    id: m17_streamer
    output_language: python
    title: M17 data streamer
  states: {}

blocks:
- name: dst_id
  id: variable_qtgui_entry
  parameters:
    type: string
    value: RECEIV
  states: {}
- name: meta
  id: variable_qtgui_entry
  parameters:
    type: string
    value: metastring
  states: {}
- name: mtype
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: src_id
  id: variable_qtgui_entry
  parameters:
    type: string
    value: EMITTR
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: (6+6+2+14+16)*8*(1000/40)
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    debug: 'False'
    dst_id: RECEIV
    meta: meta
    samp_rate: samp_rate
    src_id: EMITTR
    type: mtype
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    debug_ctrl: 'True'
    debug_data: 'False'
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: byte
  states: {}

connections:
- [blocks_throttle_0, '0', m17_m17_decoder_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_0_2, '0', m17_m17_coder_0, '0']
- [m17_m17_coder_0, '0', blocks_throttle_0, '0']
- [m17_m17_decoder_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
