options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Foundation 2026
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: transmitterPLUTOSDR
    output_language: python
    title: Simple M17 transmitter for ADALM Pluto
  states: {}

blocks:
- name: audio_frequency
  id: variable_qtgui_range
  parameters:
    label: Audio frequency
    min_len: '100'
    start: '50'
    step: '1'
    stop: '1000'
    value: '440'
  states: {}
- name: dst
  id: variable_qtgui_entry
  parameters:
    label: Destination callsign
    type: string
    value: ALL
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: RF Frequency
    type: int
    value: '433475000'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    label: Frequency error (ppm)
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: pwr
  id: variable_qtgui_range
  parameters:
    label: RF power out
    min_len: '100'
    start: '0'
    step: '1'
    stop: '80'
    value: '0'
  states: {}
- name: rf_on
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: RF out
    'true': '1'
    type: real
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: src
  id: variable_qtgui_entry
  parameters:
    label: Source callsign
    type: string
    value: AB1CDE
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*800.0)/samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '20000'
    freq: audio_frequency
    offset: '0'
    phase: '0'
    samp_rate: '8000'
    type: short
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rf_on
    type: complex
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {state: disabled}
- name: end_of_transmission
  id: variable_qtgui_msg_push_button
  parameters:
    label: End of Transmission
    msgName: EOT
    type: string
    value: ''
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: 80-pwr
    bandwidth: samp_rate*16
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq*(1+ppm*1e-6))
    samplerate: samp_rate*16
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: m17_codec2_encoder_0
  id: m17_codec2_encoder
  parameters: {}
  states: {}
- name: m17_m17_coder_0_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: '0'
    continuous: 'False'
    debug: 'False'
    dst_id: dst
    encr_subtype: '0'
    encr_type: '0'
    eot_cnt: '1'
    key: ''
    meta: ''
    meta_alt: '0.0'
    meta_bearing: '0'
    meta_cf1: ''
    meta_cf2: ''
    meta_hex: ''
    meta_lat: '0.0'
    meta_lon: '0.0'
    meta_source: '0'
    meta_speed: '0.0'
    meta_station: '0'
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: src
    type: '5'
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}
- name: note_0_2_1
  id: note
  parameters:
    note: 1kHz beep, can be replaced with a WAVE file source
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(samp_rate*16)
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    legend: 'False'
    name: '"RF scpectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    legend: 'False'
    name: '"M17 baseband"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    type: ccf
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}
- name: start_of_transmission
  id: variable_qtgui_msg_push_button
  parameters:
    label: Start of Transmission
    msgName: SOT
    type: string
    value: ''
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: int(freq*(1+ppm*1e-6))
    gain0: '69'
    samp_rate: samp_rate*16
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', m17_codec2_encoder_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_vector_source_x_0_2, '0', m17_m17_coder_0_0, '0']
- [end_of_transmission, pressed, m17_m17_coder_0_0, transmission_control]
- [m17_codec2_encoder_0, '0', m17_m17_coder_0_0, '0']
- [m17_m17_coder_0_0, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', iio_pluto_sink_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', uhd_usrp_sink_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [start_of_transmission, pressed, m17_m17_coder_0_0, transmission_control]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
