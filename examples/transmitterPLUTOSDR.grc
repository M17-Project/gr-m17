options:
  parameters:
    author: SP5WWP
    copyright: M17 Project, Dec 2022
    generate_options: qt_gui
    id: m17_streamer
    output_language: python
    title: M17 data streamer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate*24
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate*24*12
    tau: '75e-6'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: (6+6+2+14+16)*8*(1000/40)
    samples_per_second: samp_rate
    type: byte
  states: {state: bypassed}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '434000000'
    samplerate: samp_rate*24*10
    type: fc32
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    debug: 'False'
    dst_id: 255.255.255.255.255.255
    meta: helloworld
    samp_rate: samp_rate
    src_id: 01.02.03.04.05.06
    type: '5'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    debug: 'False'
  states: {state: disabled}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: byte
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_nbfm_tx_0, '0', iio_pluto_sink_0, '0']
- [blocks_throttle_0, '0', m17_m17_coder_0, '0']
- [blocks_vector_source_x_0_2, '0', blocks_throttle_0, '0']
- [m17_m17_coder_0, '0', analog_nbfm_tx_0, '0']
- [m17_m17_coder_0, '0', m17_m17_decoder_0, '0']
- [m17_m17_coder_0, '0', qtgui_freq_sink_x_0, '0']
- [m17_m17_coder_0, '0', qtgui_time_sink_x_0, '0']
- [m17_m17_decoder_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
