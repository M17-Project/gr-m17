options:
  parameters:
    author: SP5WWP
    copyright: M17 Project, Dec 2022
    generate_options: qt_gui
    id: m17_streamer
    output_language: python
    title: M17 data streamer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4800/8
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*800.0)/(4800.0*10.0)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: |-
      samp_rate=input bit rate
      output=24*samp_rate
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '434000000'
    samplerate: int(4800.0*10.0*16)
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    debug: 'False'
    dst_id: 255.255.255.255.255.255
    meta: helloworld
    samp_rate: samp_rate
    src_id: 01.02.03.04.05.06
    type: '5'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    debug: 'False'
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(4800.0*10.0*16)
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 4800*10
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '10'
    gain: '1'
    interp: '10'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', m17_m17_coder_0, '0']
- [blocks_vector_source_x_0_2, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0_2, '0', m17_m17_coder_0, '0']
- [m17_m17_coder_0, '0', m17_m17_decoder_0, '0']
- [m17_m17_coder_0, '0', root_raised_cosine_filter_1, '0']
- [m17_m17_decoder_0, '0', qtgui_number_sink_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_1, '0', analog_frequency_modulator_fc_0, '0']
- [root_raised_cosine_filter_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
