options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2026
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: m17_block
    output_language: python
    title: M17 loopback demo
  states: {}

blocks:
- name: CAN
  id: variable
  parameters:
    comment: 'Channel Access Number: 0..15'
    value: '0'
  states: {}
- name: df
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0:1,1
    label: Frequency offset
    start: '0'
    step: '.001'
    stop: '.2'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0:2,1
    label: Noise amplitude
    start: '0'
    step: '.01'
    stop: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0:3,1
    label: Detection threshold
    start: '0.0'
    step: '.1'
    stop: '10.0'
    value: '2.0'
  states: {}
- name: variable_qtgui_check_box_0
  id: variable_qtgui_check_box
  parameters:
    'false': '0.0'
    gui_hint: qtgui_tab_widget_0@0:4,1
    label: AFC
    'true': '1.0'
    type: real
    value: '0.0'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2*math.pi*800.0)/samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*800.0)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int((0.1*samp_rate)/2)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/dump.bin
    type: byte
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(0.1*samp_rate)
    max_iter: '4000'
    scale: 1/int(0.1*samp_rate)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_check_box_0
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '4800'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Payload
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: df
    noise_voltage: noise
    seed: '0'
    taps: '1'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2.0*math.pi*0.0015
    max_dev: '0.05'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '435000000'
    samplerate: samp_rate*16
    type: fc32
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: 2400000000-40000
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate*16
    type: fc32
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: '0'
    continuous: 'True'
    debug: 'False'
    dst_id: ALL
    encr_subtype: '0'
    encr_type: '0'
    eot_cnt: '1'
    key: ''
    meta: helloworld
    meta_alt: '0.0'
    meta_bearing: '0'
    meta_cf1: ''
    meta_cf2: ''
    meta_hex: ''
    meta_lat: '0.0'
    meta_lon: '0.0'
    meta_source: '0'
    meta_speed: '0.0'
    meta_station: '0'
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: AB1CDE
    type: (CAN<<7)|(2<<1)|1
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'False'
    debug_ctrl: 'False'
    debug_data: 'True'
    key: ''
    pub_key: ''
    seed: ''
    sw_threshold: '2.0'
    undecodable_out: '0'
    vt_threshold: '30.0'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    gui_hint: qtgui_tab_widget_0@1:1,1
    label1: M17
    legend: 'False'
    samp_per_symbol: '1'
    size: '4800'
    srate: '48000'
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Settings
    label1: Eye diagram
    num_tabs: '2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: fir_filter_fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', iio_pluto_sink_0, '0']
- [analog_frequency_modulator_fc_0, '0', virtual_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_delay_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0, '0', blocks_sub_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0, '1']
- [blocks_sub_xx_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_throttle2_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_vector_source_x_0, '0', m17_m17_coder_0, '0']
- [channels_channel_model_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_symbol_sync_xx_0, '0', m17_m17_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [iio_pluto_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [m17_m17_coder_0, '0', blocks_throttle2_0, '0']
- [m17_m17_decoder_0, '0', blocks_file_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [root_raised_cosine_filter_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
