options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: audiocoder
    output_language: python
    title: Speech codec demo
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    start: '50'
    step: '1'
    stop: '1000'
    value: '440'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: x
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '1'
    value: '.5'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '20000'
    freq: f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: short
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate*6
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-x
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: x
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: m17_codec2_decoder_0
  id: m17_codec2_decoder
  parameters: {}
  states: {}
- name: m17_codec2_encoder_0
  id: m17_codec2_encoder
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*6
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    nconnections: '2'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_short_to_float_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_short_to_float_0_1, '0']
- [analog_sig_source_x_0, '0', m17_codec2_encoder_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_short_to_float_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_short_to_float_0_1, '0', rational_resampler_xxx_0_1, '0']
- [m17_codec2_decoder_0, '0', blocks_short_to_float_0, '0']
- [m17_codec2_encoder_0, '0', m17_codec2_decoder_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
