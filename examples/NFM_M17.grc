options:
  parameters:
    author: Barry Duggan
    description: NBFM transmitter
    generate_options: qt_gui
    id: NFM_xmt
    output_language: python
    title: NFM_xmt
  states: {}

blocks:
- name: df
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '0.02'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: samp_rate/2
    value: '440'
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: int(usrp_rate/3)
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '2'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: if_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: if_rate
    tau: '75e-6'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: (int)(usrp_rate/if_rate)
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: df
    noise_voltage: noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: if_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: usrp_rate/6
    decim: int(usrp_rate/if_rate)
    gain: '1'
    samp_rate: usrp_rate
    type: fir_filter_ccf
    width: usrp_rate/64
    win: window.WIN_HAMMING
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    debug: 'False'
    dst_id: ALL
    meta: meta
    src_id: EMITTER1
    type: '42'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    debug_ctrl: 'True'
    debug_data: 'False'
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: if_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '1'
    interp: '10'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '10'
    gain: '1'
    interp: '10'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1.0'
    type: fir_filter_fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tag1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tag1
  states: {}

connections:
- [analog_agc_xx_0, '0', m17_m17_decoder_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [analog_nbfm_rx_0, '0', qtgui_time_sink_x_0, '1']
- [analog_nbfm_rx_0, '0', root_raised_cosine_filter_0_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_repeat_0_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_vector_source_x_0_2, '0', m17_m17_coder_0, '0']
- [channels_channel_model_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', blocks_repeat_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '2']
- [m17_m17_coder_0, '0', qtgui_time_sink_x_0_0, '0']
- [m17_m17_coder_0, '0', root_raised_cosine_filter_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']
- [root_raised_cosine_filter_0, '0', analog_nbfm_tx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_0_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
