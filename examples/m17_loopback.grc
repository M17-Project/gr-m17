options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Project, Jan 2024
    generate_options: qt_gui
    id: m17_loopback
    output_language: python
    title: M17 loopback demo
  states: {}

blocks:
- name: dst_str
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,1
    label: DST
    type: string
    value: AB2CDE
  states: {}
- name: enc_subtype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0,1,1
    label: Encr. Subtype
    label0: Text
    label1: Geolocation
    label2: Extended callsign data
    label3: Reserved
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: enc_type
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,0,1,1
    label: Encr. Type
    label0: None
    label1: Scrambler
    label2: AES
    label3: Other/Reserved
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,1
    label: Mode
    label0: Stream
    label1: Packet
    num_opts: '2'
    option0: '1'
    option1: '2'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: signed_str
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    label: SignedStr
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: src_str
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: SRC
    type: string
    value: AB1CDE
  states: {}
- name: type_val
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,0,1,1
    label: Type
    label0: Data
    label1: Voice
    label2: Data + Voice
    label3: Reserved
    num_opts: '4'
    option0: '1'
    option1: '2'
    option2: '3'
    option3: '0'
    type: int
    value: '2'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/dump.bin
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00)
  states: {}
- name: end_of_transmission
  id: variable_qtgui_msg_push_button
  parameters:
    label: End of Transmission
    msgName: end_of_transmission
    type: string
    value: end_of_transmission
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: '0'
    comment: |-
      since Meta can be a byte array, it cannot be fed with a QT GUI Entry
      string but must be a "\x00" string in the Encoder block
    debug: 'True'
    dst_id: dst_str
    encr_subtype: enc_subtype
    encr_type: enc_type
    key: '''\x00\x00\x65\x41\xb0\x93\xff\x00'''
    meta: '''\x00\x00\x65\x41\xb0\x93\xff\x00'''
    mode: mode
    priv_key: ''
    seed: ''
    signed_str: signed_str
    src_id: src_str
    type: type_val
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'False'
    debug_ctrl: 'True'
    debug_data: 'True'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    threshold: '2.0'
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: DATA
  states: {}

connections:
- [blocks_throttle2_0, '0', m17_m17_decoder_0, '0']
- [blocks_vector_source_x_0_2, '0', m17_m17_coder_0, '0']
- [end_of_transmission, pressed, m17_m17_coder_0, end_of_transmission]
- [m17_m17_coder_0, '0', blocks_throttle2_0, '0']
- [m17_m17_decoder_0, '0', blocks_file_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
